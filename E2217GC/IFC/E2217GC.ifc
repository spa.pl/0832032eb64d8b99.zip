Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2x3 Coordination View
File name: D:\Jonas\Documents\Cadfocus\Tylo\Projekt\2012-07-02_CAD-objekt_EVOLVE_GC\E2217GC\AutoCAD Architecture\E2217GC.ifc
Time: 2012-07-06T13:45:57
Author: - -
Organization: TYLÖ AB
Written by: Eurostep IFC Toolbox - 1.0
Made in: AutoCAD Architecture 2009 Build 5.7.68.0

# IfcProject, E2217GC
LongName: E2217GC
PSET_ACA_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: 02 - Normal detaljering; ACA_DISPLAY_SET_ON_EXPORT: 3D Normal

# IfcBuilding, E2217GC
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm

# IfcBuildingElementProxy: E2217GC, BUILDINGELEMENTPROXY(1)
In: E2217GC
Description: Tylö SAUNA E2217 PLUS GC ASPEN ARTNR: 95106716 ASPEN LEFT/95106717 ASPEN RIGHT
